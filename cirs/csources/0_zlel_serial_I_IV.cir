I1 0 1 0 0 10 0 0 0
I3 0 1 0 0 5 0 0 0
I2 1 0 0 0 10 0 0 0
R1 1 0 0 0 1e3 0 0 0

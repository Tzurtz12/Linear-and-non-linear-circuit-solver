I1  0 1 0 0   10 0 0  0
I13 1 2 0 0   5 0 0   0
R1  2 1 0 0   1e3 0 0 0
R12 1 0 0 0   1e3 0 0 0
I3  3 2 0 0   10 0 0  0
I4  0 3 0 0   5 0 0   0
I5  0 3 0 0   5 0 0   0

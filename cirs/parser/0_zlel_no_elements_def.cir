V1 1 0 0 0 10 0 0
R1 1 2 0 0 1e3 0 0 0
R2 2 20 0 0 2e3 0 0 0
R4 0 20 0 0 4e3 0 0 0
Q1 2 20 0 0 7e-14 1e-13 100 0
R3 2 7 0 0 1E3 0 0 0
rab 7 0 0 0 200 0 0 0
gm 0 7 0 0 4 0 0 R3

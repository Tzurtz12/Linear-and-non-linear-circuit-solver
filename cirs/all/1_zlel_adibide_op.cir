I01 0 1 0 0 1 0 0 0
r10 1 0 0 0 4 0 0 0
r13 1 3 0 0 1 0 0 0
h21 2 1 0 0 4 0 0 r30
r20 2 0 0 0 1 0 0 0
g23 3 2 0 0 2 0 0 r13
r30 3 0 0 0 4 0 0 0
r34 3 4 0 0 2 0 0 0
v40 4 0 0 0 10 0 0 0
.op 0 0 0 0 0 0 0 0

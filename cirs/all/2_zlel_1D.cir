V1 1 0 0 0 5 0 0 0
D1 1 2 0 0 1e-13 1 0 0
R1 2 0 0 0 1e3 0 0 0
.pr 0 0 0 0 0 0 0 0
.op 0 0 0 0 0 0 0 0

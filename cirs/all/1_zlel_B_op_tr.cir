r10 1 0 0 0 1e3 0 0 0
B20 1 0 0 0 10 0.05 0 0
.op 0 0 0 0 0 0 0 0
.tr 0 0 0 0 1 20 0.1 0

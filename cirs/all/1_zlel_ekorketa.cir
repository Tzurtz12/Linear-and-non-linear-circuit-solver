r01 2 1 0 0 1e3 0 0 0
R02 0 2 0 0 2e3 0 0 0
vin 1 0 0 0 3 0 0 0
R03 2 3 0 0 200 0 0 0
i01 0 3 0 0 -1e-3 0 0 0
r04 2 4 0 0 2.5e3 0 0 0
f01 4 5 0 0 4 0 0 R01
rout 5 0 0 0 10e3 0 0 0
.dc 0 0 0 0 3 36 3 vin

V01  1 0 0 0  10 0 0 		0
R01  1 2 0 0  2e3 0 0		0
D01  2 0 0 0  1e-13 1 0		0
R02  2 3 0 0  1e3 0 0		0
D02  3 0 0 0  5E-13 0.9 0	0
.pr  0 0 0 0  0 0 0   0
.OP  0 0 0 0  0 0 0		0

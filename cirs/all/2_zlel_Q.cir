V1 1 0 0 0 10 0 0 0
R1 1 2 0 0 47e3 0 0 0
R2 2 0 0 0 8.2e3 0 0 0
Q1 3 2 4 0 7e-14 1e-13 100 0
RC 1 3 0 0 3.3E3 0 0 0
RE 4 0 0 0 560 0 0 0
.pr 0 0 0 0 0 0 0 0
.op 0 0 0 0 0 0 0 0

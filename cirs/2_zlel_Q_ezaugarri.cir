I01		0 1 0 0 1e-5 0 0 			    0
V01		2 0 0 0 5 0 0 				    0
Q01		2 1 0 0	7e-14 1e-13 100		0
.pr 0 0 0 0 0 0 0 0
.DC		0 0 0 0	0 2 0.01				  v01

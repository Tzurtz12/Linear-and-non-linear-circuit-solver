I1 4 1 0 0 5 0 0 0
I13 1 2 0 0 5 0 0 0
R1 2 1 0 0 1e3 0 0 0
R12 1 0 0 0 1e3 0 0 0
I3 3 2 0 0 10 0 0 0
I4 4 3 0 0 5 0 0 0
I5 4 3 0 0 5 0 0 0
q2 2 4 3 0 7e-14 1e-13 100 0

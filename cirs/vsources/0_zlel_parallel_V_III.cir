V1 1 0 0 0 1 0 0 0
V2 1 2 0 0 10 0 0 0
V3 0 1 0 0 20 0 0 0
R1 2 0 0 0 1e3 0 0 0

A10 1 2 3 0 0 0 0 0
V10 1 0 0 0 10 0 0 0
R40 2 0 0 0 4E3 0 0 0
r10 3 5 0 0 1e3 0 0 0
r20 5 4 0 0 2e30 0 0 0
r30 4 2 0 0 3e30 0 0 0
A20 0 5 4 0 0 0 0 0

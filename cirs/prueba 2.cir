vin	1 0 0 0 5 0 0 0
r01	1 2 0 0 1e3 0 0 0
i1 2 0 0 0 1 0 0 0
.op 0 0 0 0 0 0 0 0
